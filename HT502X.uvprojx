# Keil uVision project HT502X.uvprojx, settings and files
target HT502X (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT5027 hitrendtech
  pack: hitrendtech.HT502X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HT502X +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\ARMCM0\Include;.\lib\FreeRTOS\FreeRTOS-Kernel\include;.\lib\FreeRTOS\FreeRTOS-Port;.\lib\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM0
  asm include: .\lib\FreeRTOS\FreeRTOS-Port
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group ARMCM0
    ./ARMCM0/Source/: system_ARMCM0.c
    ./ARMCM0/Source/ARM/: startup_ARMCM0.s
  group Main
    ./: main.c
  group FreeRTOS
    ./lib/FreeRTOS/FreeRTOS-Port/: freertos.c FreeRTOSConfig.h
    ./lib/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./lib/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
    ./lib/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
